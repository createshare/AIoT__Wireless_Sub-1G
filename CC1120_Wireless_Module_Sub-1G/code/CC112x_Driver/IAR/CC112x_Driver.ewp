# IAR project CC112x_Driver.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F6638 MSP430F6638
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: D:\CC112x_Driver\Project\Code\Main; D:\CC112x_Driver\Project\Code\F5xx_F6xx_Core_Lib; D:\CC112x_Driver\Project\Code\CC112x
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F6638.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group CC112x
    ../Code/CC112x/: cc112x_easy_link.c cc112x_easy_link.h cc112x_spi.c cc112x_spi.h hal_defs.h hal_spi_rf_trxeb.c hal_spi_rf_trxeb.h hal_types.h
  group F5xx_F6xx_Core_Lib
    ../Code/F5xx_F6xx_Core_Lib/: HAL_PMM.c HAL_PMM.h
  group Main
    ../Code/Main/: Hardware_Profile.h Key.c Key.h Main.c System.c System.h
